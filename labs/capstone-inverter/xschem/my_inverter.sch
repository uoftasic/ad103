** sch_path: labs/capstone-inverter/xschem/my_inverter.sch
**.subckt my_inverter
Vdd vdd 0 1.8
Vin in 0 0
**.ends
.end
