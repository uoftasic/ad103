** sch_path: labs/lab-01-first-schematic/xschem/my_probe.sch
**.subckt my_probe
Vgs g 0 1.8
Vds d 0 1.8
**.ends
.end
